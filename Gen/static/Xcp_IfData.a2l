/begin A2ML
  A2ML_VERSION 1 0
/end A2ML

/begin IF_DATA XCP_ON_CAN_P1
  /* XCP on CAN v1.1 */
  0x0101
  CAN_ID_MASTER 0x0
  CAN_ID_SLAVE 0x1
  BAUDRATE 500000
  MAX_CTO 8
  MAX_DTO 8
  IDENTIFICATION_FIELD_TYPE ABSOLUTE
  TIMESTAMP_TYPE FOUR_BYTE
  TIMESTAMP_UNIT TIMESTAMP_UNIT_1MS
  TIMESTAMP_TICKS 1
  TIMESTAMP_FIXED 0
  DAQ_CONFIG_TYPE DAQ_STATIC
  MIN_DAQ 1
  MAX_DAQ 8
  MAX_ODT 4
  MAX_ODT_ENTRIES 7
  MAX_EVENT_CHANNEL 4
  DAQ_SUPPORTED 1
  PGM_SUPPORTED 1
  CAL_PAGE_SUPPORTED 1
  RESUME_SUPPORTED 1
  SEED_AND_KEY 1
  MAIN_FUNCTION_PERIOD 1
/end IF_DATA
