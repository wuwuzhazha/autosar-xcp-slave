/begin A2ML
  A2ML_VERSION 1 0
/end A2ML

/begin IF_DATA XCP_ON_ETHERNET_IPV4
  0x0101
  HOST_NAME "ECU"
  PORT 5555
  MAX_CTO 8
  MAX_DTO 8
  IDENTIFICATION_FIELD_TYPE ABSOLUTE
  TIMESTAMP_TYPE FOUR_BYTE
  TIMESTAMP_UNIT TIMESTAMP_UNIT_1MS
  TIMESTAMP_TICKS 1
  TIMESTAMP_FIXED 0
  DAQ_CONFIG_TYPE DAQ_DYNAMIC
  MIN_DAQ 0
  MAX_DAQ 8
  MAX_ODT 4
  MAX_ODT_ENTRIES 7
  MAX_EVENT_CHANNEL 4
  DAQ_SUPPORTED 1
  PGM_SUPPORTED 1
  CAL_PAGE_SUPPORTED 1
  RESUME_SUPPORTED 1
  SEED_AND_KEY 1
  MAIN_FUNCTION_PERIOD 1
/end IF_DATA
